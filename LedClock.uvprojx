# Keil uVision project LedClock.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030F4Px STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: LedClock +hex
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F030x6
  c include: .\BSP\inc;.\Drivers\CMSIS\Include;.\Drivers\CMSIS\Device\ST\STM32F0xx\Include;.\Drivers\STM32F0xx_HAL_Driver\Inc;.\App;.\Test
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group App
    ./App/: app_alarm.c app_display.c app_interrupt_handler.c app_modekey.c app_setkey.c app_settings.c app_state.c main.c stm32f0xx_hal_msp.c system_stm32f0xx.c app_alarm.h app_config.h app_display.h app_interrupt_handler.h app_modekey.h app_setkey.h app_settings.h app_state.h stm32f0xx_hal_conf.h
  group BSP
    ./BSP/src/: adc.c dma.c exti.c key.c sd3077.c tim.c tm1637.c delay.c
  group HAL
    ./Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_cortex.c stm32f0xx_hal_dma.c stm32f0xx_hal_exti.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c
  group StartUp
    ./Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/: startup_stm32f030x6.s
  group TEST
    ./Test/: factory_test.c factory_test.h
